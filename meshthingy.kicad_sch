File: meshthingy.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: finalize
Other:
- sheet Peripherals ports: added none; removed SPI_CS_N
